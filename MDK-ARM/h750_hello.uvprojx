# Keil uVision project h750_hello.uvprojx, settings and files
target h750_hello (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: h750_hello +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,USE_FULL_ASSERT,__ARM_PCS_VFP,__FPU_PRESENT=1,ARM_MATH_CM7,ARM_MATH_MATRIX_CHECK
  c include: ../Inc;              ../Drivers/STM32H7xx_HAL_Driver/Inc;              ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;              ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;              ../Drivers/CMSIS/Include;              ..\App;              ..\App\hal;              ..\App\hardware;              ..\App\rom;              ..\Drivers\CMSIS\DSP\Include;              ..\App\lcd;              ..\App\lcd\UGUI;            ../Utilities/JPEG
  library: MicroLIB
  memory RVCT3: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x0 size 0x10000
  memory RVCT8: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c
  group Utilities
    ../Utilities/JPEG/: jpeg_utils.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dac.c debug.c dma.c hrtim.c jpeg.c pwr.c quadspi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Devices/DSP_LIB
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group hardware
    ../App/hardware/: qspi_flash.c hrtim_4switch_pwm.c hal32_adc.c key_inout.c
  group hal
    ../App/hal/: data_interface_hal.c
  group DISPLAY
    ../App/lcd/: lcd240x240.c lcd_manager.c
    ../App/lcd/UGUI/: ugui.c
  group App
    ../App/: debug_uart.c user_main.c user_main.h kfifo.c adc_algorithm.c soft_timer.c mat_algorithm.c
    ../App/rom/: tts.c
  group FLASH_8M_0x90000000
    ../App/rom/: pcm.c
    ../App/lcd/: bmp.c
software components: CMSIS:CORE 5.2.0
